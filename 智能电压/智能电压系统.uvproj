# Keil uVision project 智能电压系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能电压系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Software\keil\C51\INC\STC
  group Source Group 1
    ./: main.c ds1302.c seg.c key.c iic.c
